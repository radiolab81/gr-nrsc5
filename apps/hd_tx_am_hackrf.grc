options:
  parameters:
    generate_options: no_gui
    id: hd_tx_am_hackrf
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1710e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(audio_rate * 5.5)
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * math.pi * 100000 / samp_rate'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: sample_mono.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: sample_mono.wav
    repeat: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(256)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '4500'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52004'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52000'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: nrsc5_am_pulse_shaper_0
  id: nrsc5_am_pulse_shaper
  parameters: {}
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '17900'
    channels: '1'
  states: {}
- name: nrsc5_l1_am_encoder_ma1_0
  id: nrsc5_l1_am_encoder_ma1
  parameters:
    aab: '0'
    hpp: '0'
    pl: '0'
    rdb: '0'
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    blend_control: nrsc5.blend.ENABLE
    ccc_width: '1'
    data_bytes: '4'
    first_prog: '0'
    num_progs: '1'
    size: '3750'
  states: {}
- name: nrsc5_l2_encoder_1
  id: nrsc5_l2_encoder
  parameters:
    blend_control: nrsc5.blend.ENABLE
    ccc_width: '24'
    data_bytes: '2048'
    first_prog: '0'
    num_progs: '0'
    size: '24000'
  states: {}
- name: nrsc5_lot_encoder_0
  id: nrsc5_lot_encoder
  parameters:
    filename: SLABCD$$010000.png
    lot_id: '42'
    port: '0x1001'
  states: {}
- name: nrsc5_lot_encoder_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1337'
    port: '0x1000'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: Artist
    bytes_per_frame: '64'
    prog_num: '0'
    title: Title
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    altitude: '93.0'
    country_code: US
    emergency_alerts: 'False'
    fcc_facility_id: '0'
    latitude: '40.6892'
    longitude: '-74.0445'
    message: Generated by GNU Radio
    mode: nrsc5.pids_mode.AM
    num_programs: '1'
    program_name0: HD1
    program_name1: HD2
    program_name2: HD3
    program_name3: HD4
    program_name4: HD5
    program_name5: HD6
    program_name6: HD7
    program_name7: HD8
    program_type0: nrsc5.program_type.NEWS
    program_type1: nrsc5.program_type.NEWS
    program_type2: nrsc5.program_type.NEWS
    program_type3: nrsc5.program_type.NEWS
    program_type4: nrsc5.program_type.NEWS
    program_type5: nrsc5.program_type.NEWS
    program_type6: nrsc5.program_type.NEWS
    program_type7: nrsc5.program_type.NEWS
    short_name: ABCD
    slogan: This is ABCD-AM
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    bw0: 1.5e6
    freq0: freq + 100000
    gain0: '0'
    if_gain0: '35'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '200'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    interp: '4096'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', low_pass_filter_1, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', osmosdr_sink_0, '0']
- [blocks_wavfile_source_0, '0', nrsc5_hdc_encoder_0, '0']
- [blocks_wavfile_source_1, '0', blocks_delay_0, '0']
- [fft_vxx_0, '0', nrsc5_am_pulse_shaper_0, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [network_socket_pdu_0, pdus, nrsc5_lot_encoder_0_0, file]
- [network_socket_pdu_0_0, pdus, nrsc5_sis_encoder_0, command]
- [network_socket_pdu_1, pdus, nrsc5_psd_encoder_0, set_meta]
- [nrsc5_am_pulse_shaper_0, '0', rational_resampler_xxx_1, '0']
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_l1_am_encoder_ma1_0, '0', fft_vxx_0, '0']
- [nrsc5_l1_am_encoder_ma1_0, clock, nrsc5_l2_encoder_1, clock]
- [nrsc5_l1_am_encoder_ma1_0, clock, nrsc5_psd_encoder_0, clock]
- [nrsc5_l1_am_encoder_ma1_0, clock, nrsc5_sis_encoder_0, clock]
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_am_encoder_ma1_0, '1']
- [nrsc5_l2_encoder_0, ready, nrsc5_sis_encoder_0, ready]
- [nrsc5_l2_encoder_1, '0', nrsc5_l1_am_encoder_ma1_0, '2']
- [nrsc5_l2_encoder_1, ready, nrsc5_lot_encoder_0, ready]
- [nrsc5_l2_encoder_1, ready, nrsc5_lot_encoder_0_0, ready]
- [nrsc5_lot_encoder_0, aas, nrsc5_l2_encoder_1, aas]
- [nrsc5_lot_encoder_0_0, aas, nrsc5_l2_encoder_1, aas]
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_am_encoder_ma1_0, '0']
- [nrsc5_sis_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
